<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tutorial_7_LDPC</value></param>
<param><key>author</key><value>Andre Silva</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Tutorial</value></param>
</block>
<block>
<key>variable_ldpc_H_matrix_def</key>
<param><key>id</key><value>H</value></param>
<param><key>filename</key><value>/usr/local/share/gnuradio/fec/ldpc/n_1100_k_0442_gap_24.alist</value></param>
<param><key>gap</key><value>24</value></param>
</block>
<block>
<key>variable_ldpc_H_matrix_def</key>
<param><key>id</key><value>H_dec</value></param>
<param><key>filename</key><value>/usr/local/share/gnuradio/fec/ldpc/n_1100_k_0442_gap_24.alist</value></param>
<param><key>gap</key><value>24</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>0.22</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_constellation_rect</key>
<param><key>id</key><value>pld_const</value></param>
<param><key>const_points</key><value>[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]</value></param>
<param><key>imag_sect</key><value>2</value></param>
<param><key>real_sect</key><value>2</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>sym_map</key><value>[0, 1, 2, 3]</value></param>
<param><key>w_imag_sect</key><value>1</value></param>
<param><key>w_real_sect</key><value>1</value></param>
</block>
<block>
<key>variable_ldpc_bit_flip_decoder_def</key>
<param><key>id</key><value>pld_dec</value></param>
<param><key>dim1</key><value>8</value></param>
<param><key>matrix_object</key><value>H_dec</value></param>
<param><key>max_iterations</key><value>10</value></param>
<param><key>ndim</key><value>1</value></param>
</block>
<block>
<key>variable_ldpc_encoder_H_def</key>
<param><key>id</key><value>pld_enc</value></param>
<param><key>dim1</key><value>4</value></param>
<param><key>ndim</key><value>1</value></param>
<param><key>H</key><value>H</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>punc_pattern</value></param>
<param><key>value</key><value>4294967294</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>punc_pattern_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>0xFFF7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>punc_replace</value></param>
<param><key>value</key><value>127</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>punc_replace_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>127</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>punc_size</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>punc_size_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>11*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts*sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>3000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>tx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>11*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_2_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/andre/Desktop/Trasmited/depois.txt</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/andre/Desktop/Trasmited/seq_coded_eliminar.txt</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2</value></param>
<param><key>file</key><value>/home/andre/Desktop/Trasmited/seq_unpacked.txt</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2_0</value></param>
<param><key>file</key><value>/home/andre/Desktop/Trasmited/seq_unpacked_punc.txt</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2_0_0</value></param>
<param><key>file</key><value>/home/andre/Desktop/Trasmited/seq_unpacked_depunc.txt</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_1_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/andre/Desktop/Files_To_Transmit/book.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_1_0_0_1</value></param>
<param><key>file</key><value>/home/andre/Desktop/Files_To_Transmit/sequence55bytes_abc.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0_2_0_0</value></param>
<param><key>comment</key><value>Use when Constellation Soft Decoder</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>m</key><value>1100</value></param>
<param><key>n</key><value>1104</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0_2_0_0_0</value></param>
<param><key>comment</key><value>Use when Constellation Soft Decoder</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>m</key><value>1100</value></param>
<param><key>n</key><value>1104</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value></value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_1_0_0_1</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value></value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>lengths</key><value>1100, 4</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>lengths</key><value>440, 2</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>lengths</key><value>155, 1104</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>[0x0, 0x0, 0x1, 0x1, 0x1, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x1, 0x1, 0x1, 0x1, 0x0, 0x1, 0x1, 0x0, 0x1, 0x1, 0x1, 0x1, 0x0, 0x0, 0x1, 0x0, 0x0, 0x1, 0x0, 0x0, 0x1, 0x1, 0x1, 0x0, 0x1, 0x1, 0x0, 0x0, 0x0, 0x1, 0x1, 0x1, 0x1, 0x0, 0x0, 0x1, 0x0, 0x0, 0x1, 0x1, 0x0, 0x1, 0x0, 0x1, 0x1, 0x0, 0x0, 0x1, 0x1, 0x0, 0x1, 0x1, 0x1, 0x0, 0x1, 0x1, 0x0, 0x1, 0x0, 0x0, 0x1, 0x0, 0x0, 0x1, 0x1, 0x1, 0x0, 0x0, 0x0, 0x1, 0x0, 0x1, 0x1, 0x1, 0x1, 0x0, 0x0, 0x1, 0x0, 0x1, 0x0, 0x0, 0x0, 0x1, 0x1, 0x0, 0x0, 0x0, 0x0, 0x1, 0x0, 0x0, 0x0, 0x0, 0x0, 0x1, 0x1, 0x1, 0x1, 0x1, 0x1, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x1, 0x0, 0x0, 0x0, 0x1, 0x0, 0x1, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x1, 0x0, 0x0, 0x0, 0x1, 0x0, 0x1, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0]</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>[0]</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>[0]</value></param>
</block>
<block>
<key>cac_cpp_cac_bb</key>
<param><key>id</key><value>cac_cpp_cac_bb_0</value></param>
<param><key>access_code</key><value>digital.packet_utils.default_access_code</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>threshold</key><value>1</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>map</key><value>[-1, 1]</value></param>
</block>
<block>
<key>fec_depuncture_bb</key>
<param><key>id</key><value>fec_depuncture_bb_0</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>puncpat</key><value>punc_pattern</value></param>
<param><key>puncsize</key><value>punc_size</value></param>
<param><key>sym</key><value>punc_replace</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0_0_1_0_1_0_0</value></param>
<param><key>decoder_list</key><value>pld_dec</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>puncpat</key><value>puncpat</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>fec_extended_encoder</key>
<param><key>id</key><value>fec_extended_encoder_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>encoder_list</key><value>pld_enc</value></param>
<param><key>puncpat</key><value>puncpat</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>fec_puncture_xx</key>
<param><key>id</key><value>fec_puncture_xx_0</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>puncpat</key><value>punc_pattern</value></param>
<param><key>puncsize</key><value>punc_size</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>puncpat</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'11'</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0_2_0_0_0</source_block_id><sink_block_id>fec_extended_decoder_0_0_1_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_1_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_1_0_0_1</source_block_id><sink_block_id>blocks_repack_bits_bb_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_2_0_0</source_block_id><sink_block_id>digital_map_bb_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_2_0_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_1_0_0_1</source_block_id><sink_block_id>blocks_file_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_1_0_0_1</source_block_id><sink_block_id>blocks_stream_mux_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_1_0_0_1</source_block_id><sink_block_id>fec_puncture_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_0_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_0_0</source_block_id><sink_block_id>fec_puncture_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_0_0_0</source_block_id><sink_block_id>fec_extended_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_1_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>cac_cpp_cac_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>cac_cpp_cac_bb_0</source_block_id><sink_block_id>fec_depuncture_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_char_to_float_0_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_depuncture_bb_0</source_block_id><sink_block_id>blocks_file_sink_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_depuncture_bb_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_depuncture_bb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0_0_1_0_1_0_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_encoder_0</source_block_id><sink_block_id>blocks_stream_mux_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_puncture_xx_0</source_block_id><sink_block_id>blocks_file_sink_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_puncture_xx_0</source_block_id><sink_block_id>blocks_stream_mux_0_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fec_puncture_xx_0</source_block_id><sink_block_id>fec_depuncture_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
