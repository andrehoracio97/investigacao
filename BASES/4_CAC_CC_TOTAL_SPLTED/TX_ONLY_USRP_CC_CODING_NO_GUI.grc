<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tx_encode_no_gui</value></param>
<param><key>author</key><value>andresilva</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>MCR</value></param>
<param><key>value</key><value>"master_clock_rate=60e6"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>0.22</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequencia_usrp</value></param>
<param><key>value</key><value>484e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_constellation_rect</key>
<param><key>id</key><value>pld_const</value></param>
<param><key>const_points</key><value>[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]</value></param>
<param><key>imag_sect</key><value>2</value></param>
<param><key>real_sect</key><value>2</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>sym_map</key><value>[0, 1, 2, 3]</value></param>
<param><key>w_imag_sect</key><value>1</value></param>
<param><key>w_real_sect</key><value>1</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>pld_enc</value></param>
<param><key>padding</key><value>True</value></param>
<param><key>k</key><value>k</value></param>
<param><key>dim1</key><value>8</value></param>
<param><key>framebits</key><value>440</value></param>
<param><key>ndim</key><value>1</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polys</value></param>
<param><key>value</key><value>[109, 79]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>samp_rate_array_MCR[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_array_MCR</value></param>
<param><key>value</key><value>[7500000,5000000,3750000,3000000,2500000,2000000,1500000,1000000,937500,882352,833333,714285,533333,500000,421052,400000,380952]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>tx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>5*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>variable_qtgui_range_0</value></param>
<param><key>value</key><value>50</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,1,1,3</value></param>
<param><key>label</key><value>Gain_TX</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>90</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/andre/Desktop/TX_TEMP.txt</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/andre/Desktop/Files_To_Transmit/trasmit_10_mb.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_1_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/andre/Desktop/Files_To_Transmit/videofhd.mpg</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_1_0_0_0</value></param>
<param><key>file</key><value>/home/andre/Desktop/Files_To_Transmit/video_lion.mpeg</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value></value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_1_0_0_1</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value></value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>440, 2</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_0</value></param>
<param><key>lengths</key><value>892, 4</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>[0]</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>[0]</value></param>
</block>
<block>
<key>fec_extended_encoder</key>
<param><key>id</key><value>fec_extended_encoder_0</value></param>
<param><key>encoder_list</key><value>pld_enc</value></param>
<param><key>puncpat</key><value>puncpat</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>puncpat</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'11'</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Tx Data</value></param>
<param><key>size</key><value>100*2</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_tag</key><value>packet_length_tag_key</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>256</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_1_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_1_0</source_block_id><sink_block_id>blocks_char_to_float_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_1_0</source_block_id><sink_block_id>blocks_repack_bits_bb_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_1_0_0</source_block_id><sink_block_id>blocks_char_to_float_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_1_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_1_0_0_0</source_block_id><sink_block_id>blocks_char_to_float_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_1_0_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_1_0_0_1</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>fec_extended_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_repack_bits_bb_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fec_extended_encoder_0</source_block_id><sink_block_id>blocks_stream_mux_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
