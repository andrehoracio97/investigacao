<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tutorial_7</value></param>
<param><key>author</key><value>Andre Silva</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Tutorial</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>MCR</value></param>
<param><key>value</key><value>"master_clock_rate=60e6"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>0.22</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filt_delay</value></param>
<param><key>value</key><value>1+(taps_per_filt-1)/2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,2</value></param>
<param><key>label</key><value>Freq. Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-0.5</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequencia_usrp</value></param>
<param><key>value</key><value>484e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>label</key><value>Noise Amp</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>5</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>pld_const</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>pld_const</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>pld_const</value></param>
<param><key>type</key><value>8psk</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_constellation_rect</key>
<param><key>id</key><value>pld_const</value></param>
<param><key>const_points</key><value>[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]</value></param>
<param><key>imag_sect</key><value>2</value></param>
<param><key>real_sect</key><value>2</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>sym_map</key><value>[0, 1, 2, 3]</value></param>
<param><key>w_imag_sect</key><value>1</value></param>
<param><key>w_real_sect</key><value>1</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>11*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts*sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>samp_rate_array_MCR[2]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_array_MCR</value></param>
<param><key>value</key><value>[3750000,3000000,2500000,2000000,1500000,1000000,937500,882352,833333,714285,533333,500000,421052,400000,380952]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_per_filt</value></param>
<param><key>value</key><value>len(tx_rrc_taps)/nfilts</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>time_offset</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>0,3</value></param>
<param><key>label</key><value>Time Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.99</value></param>
<param><key>step</key><value>0.00001</value></param>
<param><key>stop</key><value>1.01</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>tx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>5*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>variable_qtgui_range_0</value></param>
<param><key>value</key><value>50</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>label</key><value>Gain_TX</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>90</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>variable_qtgui_range_0_1</value></param>
<param><key>value</key><value>36</value></param>
<param><key>gui_hint</key><value>0,2</value></param>
<param><key>label</key><value>Gain_RX</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>73</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vector</value></param>
<param><key>value</key><value>[int(random.random()*4) for i in range(49600)]</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>acode_1104</value></param>
<param><key>comment</key><value>64 bits of Access Code +
16 bits of Lenght of the Payload (112 bytes) + 
16 bits of Lenght of the Payload (112 bytes) + 
96 bits of Header</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>[0x1, 0x0, 0x1, 0x0, 0x1, 0x1, 0x0, 0x0, 0x1, 0x1, 0x0, 0x1, 0x1, 0x1, 0x0, 0x1, 0x1, 0x0, 0x1, 0x0, 0x0, 0x1, 0x0, 0x0, 0x1, 0x1, 0x1, 0x0, 0x0, 0x0, 0x1, 0x0, 0x1, 0x1, 0x1, 0x1, 0x0, 0x0, 0x1, 0x0, 0x1, 0x0, 0x0, 0x0, 0x1, 0x1, 0x0, 0x0, 0x0, 0x0, 0x1, 0x0, 0x0, 0x0, 0x0, 0x0, 0x1, 0x1, 0x1, 0x1, 0x1, 0x1, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x1, 0x1, 0x1, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x1, 0x1, 0x1, 0x0, 0x0, 0x0, 0x0]</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1_0_1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/andre/Desktop/Trasmited/depois.txt</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_2_0</value></param>
<param><key>file</key><value>/home/andre/Desktop/Trasmited/depois.mpg</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/andre/Desktop/Files_To_Transmit/trasmit_10_mb.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_1_0_0</value></param>
<param><key>file</key><value>/home/andre/Desktop/Files_To_Transmit/videofhd.mpg</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>0.7</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>pld_const.bits_per_symbol()</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value></value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value></value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_1</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>pld_const.bits_per_symbol()</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value></value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_1_0_0_1</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value></value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0_1_0</value></param>
<param><key>comment</key><value>96 bits of Header + 896 (112 bytes) of payload</value></param>
<param><key>lengths</key><value>96, 896</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>[0,85,170,255]</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>block_tags</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>epsilon</key><value>time_offset</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>noise_voltage</key><value>noise</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>taps</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>pld_const.points()</value></param>
</block>
<block>
<key>digital_cma_equalizer_cc</key>
<param><key>id</key><value>digital_cma_equalizer_cc_0</value></param>
<param><key>mu</key><value>0.01</value></param>
<param><key>modulus</key><value>1</value></param>
<param><key>num_taps</key><value>15</value></param>
<param><key>sps</key><value>2</value></param>
</block>
<block>
<key>digital_constellation_decoder_cb</key>
<param><key>id</key><value>digital_constellation_decoder_cb_0_0</value></param>
<param><key>constellation</key><value>pld_const</value></param>
</block>
<block>
<key>digital_correlate_access_code_xx_ts</key>
<param><key>id</key><value>digital_correlate_access_code_xx_ts_0_0</value></param>
<param><key>access_code</key><value>digital.packet_utils.default_access_code</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>packet_len</value></param>
<param><key>threshold</key><value>1</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0</value></param>
<param><key>w</key><value>6.28/200.0</value></param>
<param><key>order</key><value>pld_const.arity()</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>4</value></param>
</block>
<block>
<key>digital_diff_encoder_bb</key>
<param><key>id</key><value>digital_diff_encoder_bb_0</value></param>
<param><key>modulus</key><value>4</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0</value></param>
<param><key>map</key><value>pld_const.pre_diff_code()</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0_0</value></param>
<param><key>map</key><value>pld_const.pre_diff_code()</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>6.28/400.0</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>2</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import random</value></param>
</block>
<block>
<key>insert_vec_cpp_new_vec</key>
<param><key>id</key><value>insert_vec_cpp_new_vec_0</value></param>
<param><key>vec</key><value>vector</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>nfilts</key><value>nfilts</value></param>
<param><key>rrate</key><value>sps</value></param>
<param><key>samp_delay</key><value>filt_delay</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>taps</key><value>tx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_0_0</value></param>
<param><key>gui_hint</key><value>1,2</value></param>
<param><key>name</key><value>"TX Constellation"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_0_1</value></param>
<param><key>gui_hint</key><value>2,1</value></param>
<param><key>name</key><value>"RX Constellation"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0_0_0_1_0</value></param>
<param><key>gui_hint</key><value>2,2</value></param>
<param><key>name</key><value>"RX Treated Constellation"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>1,3</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"TX"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Tx Data</value></param>
<param><key>size</key><value>100*2</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_tag</key><value>packet_length_tag_key</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>256</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>2,3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Rx Data</value></param>
<param><key>size</key><value>100*2</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_tag</key><value>packet_length_tag_key</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>256</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>gui_hint</key><value>2,4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"RX"</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>frequencia_usrp</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>variable_qtgui_range_0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>comment</key><value>USE WITH BUSRT SHAPPER BYPASSED</value></param>
<param><key>dev_addr</key><value>"serial=F5EAE1"</value></param>
<param><key>dev_args</key><value>MCR</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>frequencia_usrp</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>variable_qtgui_range_0_1</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"serial=F5EAC0"</value></param>
<param><key>dev_args</key><value>MCR</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>data_after_channel</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>packet</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>data_recived</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>packet_recived</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>data_modulated</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>packet</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>data_recived</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>packet_recived</value></param>
</block>
<connection><source_block_id>acode_1104</source_block_id><sink_block_id>blocks_stream_mux_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_1_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_1_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_1_0</source_block_id><sink_block_id>blocks_char_to_float_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_1_0</source_block_id><sink_block_id>blocks_repack_bits_bb_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_1_0_0</source_block_id><sink_block_id>blocks_char_to_float_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_1_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>blocks_char_to_float_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_1</source_block_id><sink_block_id>insert_vec_cpp_new_vec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_1_0_0_1</source_block_id><sink_block_id>blocks_stream_mux_0_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0_1_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_char_to_float_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_repack_bits_bb_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>digital_costas_loop_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_decoder_cb_0_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_xx_ts_0_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>digital_constellation_decoder_cb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>digital_map_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_encoder_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0</source_block_id><sink_block_id>digital_diff_encoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_cma_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>insert_vec_cpp_new_vec_0</source_block_id><sink_block_id>digital_map_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_const_sink_x_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_repack_bits_bb_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>digital_correlate_access_code_xx_ts_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
