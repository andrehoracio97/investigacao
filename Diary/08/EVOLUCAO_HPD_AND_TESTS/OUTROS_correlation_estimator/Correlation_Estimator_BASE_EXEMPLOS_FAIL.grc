<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>novo</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>Const_HDR</value></param>
<param><key>const_points</key><value>digital.psk_2()[0]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_2()[1]</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>Const_PLD</value></param>
<param><key>const_points</key><value>digital.psk_2()[0]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_2()[1]</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>Const_PLD</value></param>
<param><key>const_points</key><value>digital.psk_4()[0]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_4()[1]</value></param>
</block>
<block>
<key>variable_dummy_decoder_def</key>
<param><key>id</key><value>dec</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_dummy_decoder_def</key>
<param><key>id</key><value>dec_hdr</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_repetition_decoder_def</key>
<param><key>id</key><value>dec_hdr</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>framebits</key><value>hdr_format.header_nbits()</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>rep</key><value>rep</value></param>
<param><key>prob</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>0.22</value></param>
</block>
<block>
<key>variable_dummy_encoder_def</key>
<param><key>id</key><value>enc</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_dummy_encoder_def</key>
<param><key>id</key><value>enc_hdr</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_repetition_encoder_def</key>
<param><key>id</key><value>enc_hdr</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>rep</key><value>rep</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filt_delay</value></param>
<param><key>value</key><value>1+(taps_per_filt-1)/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hdr_format</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>digital.header_format_default(digital.packet_utils.default_access_code, 0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hdr_format</value></param>
<param><key>value</key><value>digital.header_format_counter(digital.packet_utils.default_access_code, 3, Const_PLD.bits_per_symbol())</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mark_delay</value></param>
<param><key>value</key><value>mark_delays[sps]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mark_delays</value></param>
<param><key>comment</key><value>Tag Marking Delay for 
Corr Est block, indexed
by sps.

Found empirically.</value></param>
<param><key>value</key><value>[0, 0, 34, 56, 87, 119]</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_sync_word</value></param>
<param><key>data</key><value>preamble_dummy</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>rxmod</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ntaps</value></param>
<param><key>value</key><value>len(tx_rrc_taps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_dummy</value></param>
<param><key>comment</key><value>use when header
FEC is Dummy</value></param>
<param><key>value</key><value>[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rep</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>11*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts*sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rxmod</value></param>
<param><key>value</key><value>digital.generic_mod(Const_HDR, False, sps, True, eb, False, False)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_per_filt</value></param>
<param><key>value</key><value>len(tx_rrc_taps)/nfilts</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>tx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>5*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>file</key><value>/home/andre/Desktop/transmitido/depois.txt</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/andre/Desktop/transmit_maior.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_by_tag_value_cc</key>
<param><key>id</key><value>blocks_multiply_by_tag_value_cc_0</value></param>
<param><key>tagname</key><value>"amp_est"</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>Const_HDR.bits_per_symbol()</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>Const_PLD.bits_per_symbol()</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>100</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>DIFF OFFSET</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>MUX</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>BURST</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>MULTIPLY</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>CORRELATION</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>c</key><value>sps</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>c</key><value>Const_PLD.bits_per_symbol()</value></param>
<param><key>lengthtagname</key><value>"payload symbols"</value></param>
</block>
<block>
<key>blocks_tagged_stream_mux</key>
<param><key>id</key><value>blocks_tagged_stream_mux_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
<param><key>ninputs</key><value>2</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>"payload symbols"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>block_tags</key><value>True</value></param>
<param><key>epsilon</key><value>1</value></param>
<param><key>freq_offset</key><value>0</value></param>
<param><key>noise_voltage</key><value>0</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0</value></param>
</block>
<block>
<key>digital_burst_shaper_xx</key>
<param><key>id</key><value>digital_burst_shaper_xx_0</value></param>
<param><key>alias</key><value>burst_shaper0</value></param>
<param><key>insert_phasing</key><value>True</value></param>
<param><key>length_tag_name</key><value>packet_len</value></param>
<param><key>post_padding</key><value>filt_delay</value></param>
<param><key>pre_padding</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>window</key><value>firdes.window(firdes.WIN_HANN, 20, 0)</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>Const_HDR.points()</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>Const_PLD.points()</value></param>
</block>
<block>
<key>digital_constellation_soft_decoder_cf</key>
<param><key>id</key><value>digital_constellation_soft_decoder_cf_0</value></param>
<param><key>constellation</key><value>Const_PLD</value></param>
</block>
<block>
<key>digital_constellation_soft_decoder_cf</key>
<param><key>id</key><value>digital_constellation_soft_decoder_cf_0_0</value></param>
<param><key>constellation</key><value>Const_HDR</value></param>
</block>
<block>
<key>digital_corr_est_cc</key>
<param><key>id</key><value>digital_corr_est_cc_0</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>symbols</key><value>modulated_sync_word</value></param>
<param><key>mark_delay</key><value>mark_delay</value></param>
<param><key>threshold</key><value>0.999</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0</value></param>
<param><key>w</key><value>6.28/200.0</value></param>
<param><key>order</key><value>Const_HDR.arity()</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0_0_0</value></param>
<param><key>w</key><value>6.28/200.0</value></param>
<param><key>order</key><value>Const_PLD.arity()</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_0</value></param>
<param><key>check</key><value>True</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_1</value></param>
<param><key>check</key><value>False</value></param>
</block>
<block>
<key>digital_fll_band_edge_cc</key>
<param><key>id</key><value>digital_fll_band_edge_cc_0</value></param>
<param><key>rolloff</key><value>eb</value></param>
<param><key>w</key><value>0.05</value></param>
<param><key>filter_size</key><value>44</value></param>
<param><key>samps_per_sym</key><value>sps</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>digital_header_payload_demux</key>
<param><key>id</key><value>digital_header_payload_demux_0</value></param>
<param><key>comment</key><value>(hdr_format.header_nbits() * int(1.0/hdr_dec.rate())) /  hdr_const.bits_per_symbol()</value></param>
<param><key>header_len</key><value>(hdr_format.header_nbits() * int(1.0/dec_hdr.rate())) /  Const_HDR.bits_per_symbol()</value></param>
<param><key>header_padding</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>items_per_symbol</key><value>1</value></param>
<param><key>length_tag_key</key><value>"payload symbols"</value></param>
<param><key>output_symbols</key><value>True</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>special_tags</key><value>""</value></param>
<param><key>timing_tag_key</key><value>"rx_time"</value></param>
<param><key>trigger_tag_key</key><value>"time_est"</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_1</value></param>
<param><key>map</key><value>Const_HDR.pre_diff_code()</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_1_0</value></param>
<param><key>map</key><value>Const_PLD.pre_diff_code()</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>6.28/400.0</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>digital_protocol_formatter_async</key>
<param><key>id</key><value>digital_protocol_formatter_async_0</value></param>
<param><key>format</key><value>hdr_format</value></param>
</block>
<block>
<key>digital_protocol_parser_b</key>
<param><key>id</key><value>digital_protocol_parser_b_0</value></param>
<param><key>format</key><value>hdr_format</value></param>
</block>
<block>
<key>fec_async_decoder</key>
<param><key>id</key><value>fec_async_decoder_0</value></param>
<param><key>decoder</key><value>dec</value></param>
<param><key>mtu</key><value>1500*8</value></param>
<param><key>packed</key><value>True</value></param>
<param><key>rev_pack</key><value>False</value></param>
</block>
<block>
<key>fec_async_encoder</key>
<param><key>id</key><value>fec_async_encoder_0</value></param>
<param><key>encoder</key><value>enc</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>packed</key><value>True</value></param>
<param><key>rev_pack</key><value>False</value></param>
<param><key>rev_unpack</key><value>False</value></param>
</block>
<block>
<key>fec_async_encoder</key>
<param><key>id</key><value>fec_async_encoder_0_0</value></param>
<param><key>encoder</key><value>enc_hdr</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>packed</key><value>True</value></param>
<param><key>rev_pack</key><value>False</value></param>
<param><key>rev_unpack</key><value>False</value></param>
</block>
<block>
<key>fec_generic_decoder</key>
<param><key>id</key><value>fec_generic_decoder_0</value></param>
<param><key>decoder</key><value>dec_hdr</value></param>
<param><key>itype</key><value>float</value></param>
<param><key>otype</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hdr_const</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Header constellation</value></param>
<param><key>value</key><value>digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hdr_format</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Header Formatter</value></param>
<param><key>value</key><value>digital.header_format_default(digital.packet_utils.default_access_code, 0)</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>nfilts</key><value>nfilts</value></param>
<param><key>rrate</key><value>sps</value></param>
<param><key>samp_delay</key><value>filt_delay</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>taps</key><value>tx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pld_const</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Payload constellation</value></param>
<param><key>value</key><value>digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>psf_taps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Pulse Shape Filter</value></param>
<param><key>value</key><value>[0,]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Samples per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_by_tag_value_cc_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>digital_fll_band_edge_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_1</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>digital_map_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>digital_map_bb_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>blocks_tag_debug_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>blocks_tag_debug_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>digital_burst_shaper_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>digital_crc32_async_bb_1</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>fec_async_decoder_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_burst_shaper_xx_0</source_block_id><sink_block_id>blocks_tag_debug_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_burst_shaper_xx_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_constellation_soft_decoder_cf_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_soft_decoder_cf_0_0</source_block_id><sink_block_id>fec_generic_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>blocks_multiply_by_tag_value_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0</source_block_id><sink_block_id>blocks_tag_debug_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0</source_block_id><sink_block_id>digital_constellation_soft_decoder_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0_0_0</source_block_id><sink_block_id>digital_constellation_soft_decoder_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1</source_block_id><sink_block_id>fec_async_encoder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_fll_band_edge_cc_0</source_block_id><sink_block_id>digital_corr_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_header_payload_demux_0</source_block_id><sink_block_id>digital_costas_loop_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_header_payload_demux_0</source_block_id><sink_block_id>digital_costas_loop_cc_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_1</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_1_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_header_payload_demux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_protocol_formatter_async_0</source_block_id><sink_block_id>fec_async_encoder_0_0</sink_block_id><source_key>header</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_protocol_formatter_async_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_1</sink_block_id><source_key>payload</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>digital_protocol_parser_b_0</source_block_id><sink_block_id>digital_header_payload_demux_0</sink_block_id><source_key>info</source_key><sink_key>header_data</sink_key></connection>
<connection><source_block_id>fec_async_decoder_0</source_block_id><sink_block_id>digital_crc32_async_bb_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>fec_async_encoder_0</source_block_id><sink_block_id>digital_protocol_formatter_async_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>fec_async_encoder_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>fec_generic_decoder_0</source_block_id><sink_block_id>digital_protocol_parser_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
