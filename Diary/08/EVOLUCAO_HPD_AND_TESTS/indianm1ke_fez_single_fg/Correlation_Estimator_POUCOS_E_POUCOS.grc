<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>novo</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>Const_HDR</value></param>
<param><key>const_points</key><value>digital.psk_2()[0]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_2()[1]</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>Const_PLD</value></param>
<param><key>const_points</key><value>digital.psk_2()[0]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_2()[1]</value></param>
</block>
<block>
<key>variable_dummy_decoder_def</key>
<param><key>id</key><value>dec_hdr</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>0.22</value></param>
</block>
<block>
<key>variable_dummy_encoder_def</key>
<param><key>id</key><value>enc</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_dummy_encoder_def</key>
<param><key>id</key><value>enc_hdr</value></param>
<param><key>framebits</key><value>8000</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filt_delay</value></param>
<param><key>value</key><value>1+(taps_per_filt-1)/2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Frequency Offset (Multiples of Sub-carrier spacing)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-30</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>30</value></param>
</block>
<block>
<key>variable_header_format_default</key>
<param><key>id</key><value>hdr_format</value></param>
<param><key>access_code</key><value>digital.packet_utils.default_access_code</value></param>
<param><key>bps</key><value>1</value></param>
<param><key>threshold</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mark_delay</value></param>
<param><key>value</key><value>mark_delays[sps]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>mark_delays</value></param>
<param><key>comment</key><value>Tag Marking Delay for 
Corr Est block, indexed
by sps.

Found empirically.</value></param>
<param><key>value</key><value>[0, 0, 34, 56, 87, 119]</value></param>
</block>
<block>
<key>variable_modulate_vector</key>
<param><key>id</key><value>modulated_sync_word</value></param>
<param><key>data</key><value>preamble</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>mod</key><value>rxmod</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_voltage</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>Noise Amplitude</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.05</value></param>
<param><key>stop</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ntaps</value></param>
<param><key>value</key><value>len(tx_rrc_taps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len_tag_key</value></param>
<param><key>value</key><value>"packet_length"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>comment</key><value>use when header
FEC is Dummy</value></param>
<param><key>value</key><value>[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>11*sps*nfilts</value></param>
<param><key>samp_rate</key><value>sps*nfilts</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rxmod</value></param>
<param><key>value</key><value>digital.generic_mod(Const_HDR, False, sps, True, eb, False, False)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>snc_threshold</value></param>
<param><key>value</key><value>0.9</value></param>
<param><key>label</key><value>S&amp;C Threshold</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.05</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_per_filt</value></param>
<param><key>value</key><value>len(tx_rrc_taps)/nfilts</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>tx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>5*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0</value></param>
<param><key>file</key><value>depois.txt</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/andre/Desktop/trasmit_1_mb.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>Const_HDR.bits_per_symbol()</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packet_len_tag_key</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>Const_PLD.bits_per_symbol()</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packet_len_tag_key</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_1</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_1_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>len_tag_key</key><value>packet_len_tag_key</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>MUX</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value>TAGGED</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>c</key><value>sps</value></param>
<param><key>lengthtagname</key><value>packet_len_tag_key</value></param>
</block>
<block>
<key>blocks_tagged_stream_mux</key>
<param><key>id</key><value>blocks_tagged_stream_mux_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>lengthtagname</key><value>packet_len_tag_key</value></param>
<param><key>ninputs</key><value>2</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>()</value></param>
<param><key>vector</key><value>range(packet_len)</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>channel_in</value></param>
<param><key>stream_id</key><value>Channel</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>channel_out</value></param>
<param><key>stream_id</key><value>Channel</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>block_tags</key><value>True</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>freq_offset * 1.0 / packet_len</value></param>
<param><key>noise_voltage</key><value>noise_voltage</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0_0</value></param>
</block>
<block>
<key>digital_burst_shaper_xx</key>
<param><key>id</key><value>digital_burst_shaper_xx_0_0</value></param>
<param><key>alias</key><value>burst_shaper0</value></param>
<param><key>insert_phasing</key><value>True</value></param>
<param><key>length_tag_name</key><value>packet_len_tag_key</value></param>
<param><key>post_padding</key><value>filt_delay</value></param>
<param><key>pre_padding</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>window</key><value>firdes.window(firdes.WIN_HANN, 20, 0)</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>Const_HDR.points()</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>Const_PLD.points()</value></param>
</block>
<block>
<key>digital_constellation_soft_decoder_cf</key>
<param><key>id</key><value>digital_constellation_soft_decoder_cf_0_0</value></param>
<param><key>constellation</key><value>Const_HDR</value></param>
</block>
<block>
<key>digital_constellation_soft_decoder_cf</key>
<param><key>id</key><value>digital_constellation_soft_decoder_cf_0_1</value></param>
<param><key>constellation</key><value>Const_PLD</value></param>
</block>
<block>
<key>digital_corr_est_cc</key>
<param><key>id</key><value>digital_corr_est_cc_0_0</value></param>
<param><key>sps</key><value>1</value></param>
<param><key>symbols</key><value>modulated_sync_word</value></param>
<param><key>mark_delay</key><value>mark_delay</value></param>
<param><key>threshold</key><value>0.999</value></param>
</block>
<block>
<key>digital_header_payload_demux</key>
<param><key>id</key><value>digital_header_payload_demux_0</value></param>
<param><key>comment</key><value>(hdr_format.header_nbits() * int(1.0/hdr_dec.rate())) /  hdr_const.bits_per_symbol()</value></param>
<param><key>header_len</key><value>hdr_format.header_nbits() /  Const_HDR.bits_per_symbol()</value></param>
<param><key>header_padding</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>items_per_symbol</key><value>1</value></param>
<param><key>length_tag_key</key><value>"payload symbols"</value></param>
<param><key>output_symbols</key><value>True</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>special_tags</key><value>""</value></param>
<param><key>timing_tag_key</key><value>"rx_time"</value></param>
<param><key>trigger_tag_key</key><value>"time_est"</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_1</value></param>
<param><key>map</key><value>Const_HDR.pre_diff_code()</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_1_0</value></param>
<param><key>map</key><value>Const_PLD.pre_diff_code()</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0_1</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>6.28/400.0</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>digital_protocol_formatter_bb</key>
<param><key>id</key><value>digital_protocol_formatter_bb_0</value></param>
<param><key>format</key><value>hdr_format</value></param>
<param><key>len_tag_key</key><value>packet_len_tag_key</value></param>
</block>
<block>
<key>digital_protocol_parser_b</key>
<param><key>id</key><value>digital_protocol_parser_b_0</value></param>
<param><key>format</key><value>hdr_format</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0_0</value></param>
<param><key>nfilts</key><value>nfilts</value></param>
<param><key>rrate</key><value>sps</value></param>
<param><key>samp_delay</key><value>filt_delay</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>taps</key><value>tx_rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>Rx Spectrum</value></param>
<param><key>name</key><value>Rx Spectrum</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-60</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Rx Data</value></param>
<param><key>size</key><value>packet_len*2</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>packet_length_tag_key</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Tx Data</value></param>
<param><key>size</key><value>packet_len*3</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_tag</key><value></value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>256</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>rx_header_in</value></param>
<param><key>stream_id</key><value>Rx Header</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>rx_header_out</value></param>
<param><key>stream_id</key><value>Rx Header</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>rx_payload_in</value></param>
<param><key>stream_id</key><value>Rx Payload</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>rx_payload_out</value></param>
<param><key>stream_id</key><value>Rx Payload</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>tx_mod_data_in</value></param>
<param><key>stream_id</key><value>Tx Mod Data</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>tx_mod_data_out</value></param>
<param><key>stream_id</key><value>Tx Mod Data</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>tx_mux_stream_in</value></param>
<param><key>stream_id</key><value>Tx Mux Stream</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>tx_mux_stream_out</value></param>
<param><key>stream_id</key><value>Tx Mux Stream</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_1_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>digital_map_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>digital_map_bb_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_1</source_block_id><sink_block_id>blocks_char_to_float_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_1</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_1_0</source_block_id><sink_block_id>digital_protocol_parser_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_char_to_float_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>digital_protocol_formatter_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0_1</source_block_id><sink_block_id>tx_mod_data_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>blocks_tag_debug_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>tx_mux_stream_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>channel_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_in</source_block_id><sink_block_id>digital_corr_est_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_burst_shaper_xx_0_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_constellation_soft_decoder_cf_0_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_soft_decoder_cf_0_1</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_corr_est_cc_0_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_header_payload_demux_0</source_block_id><sink_block_id>rx_header_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_header_payload_demux_0</source_block_id><sink_block_id>rx_payload_out</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_1</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_1_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0_1</source_block_id><sink_block_id>digital_header_payload_demux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_protocol_formatter_bb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_protocol_formatter_bb_0</source_block_id><sink_block_id>blocks_tag_debug_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_protocol_parser_b_0</source_block_id><sink_block_id>digital_header_payload_demux_0</sink_block_id><source_key>info</source_key><sink_key>header_data</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_header_in</source_block_id><sink_block_id>digital_constellation_soft_decoder_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_payload_in</source_block_id><sink_block_id>digital_constellation_soft_decoder_cf_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tx_mod_data_in</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tx_mux_stream_in</source_block_id><sink_block_id>digital_burst_shaper_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
