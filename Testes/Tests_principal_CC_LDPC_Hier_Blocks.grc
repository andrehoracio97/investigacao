<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>AC_documentacao</value></param>
<param><key>comment</key><value>https://www.gnuradio.org/doc/sphinx-3.7.4/digital/blocks.html#gnuradio.digital.correlate_access_code_bb</value></param>
<param><key>value</key><value>"010101010111000100"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>AC_documentacao_2_DEFAULT</value></param>
<param><key>value</key><value>"1010110011011101101001001110001011110010100011000010000011111100"</value></param>
</block>
<block>
<key>variable_ldpc_G_matrix_def</key>
<param><key>id</key><value>G</value></param>
<param><key>filename</key><value>gr.prefix() + "/share/gnuradio/fec/ldpc/" + "n_0100_k_0058_gen_matrix.alist"</value></param>
</block>
<block>
<key>variable_ldpc_H_matrix_def</key>
<param><key>id</key><value>H</value></param>
<param><key>filename</key><value>gr.prefix() + "/share/gnuradio/fec/ldpc/" + "n_0100_k_0042_gap_02.alist"</value></param>
<param><key>gap</key><value>2</value></param>
</block>
<block>
<key>variable_ldpc_H_matrix_def</key>
<param><key>id</key><value>H</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>/usr/share/gnuradio/fec/ldpc/n_0500_k_0202_gap_11.alist</value></param>
<param><key>gap</key><value>11</value></param>
</block>
<block>
<key>variable_ldpc_H_matrix_def</key>
<param><key>id</key><value>H</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>/usr/share/gnuradio/fec/ldpc/n_0300_k_0152_gap_03.alist</value></param>
<param><key>gap</key><value>3</value></param>
</block>
<block>
<key>variable_ldpc_H_matrix_def</key>
<param><key>id</key><value>H</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>filename</key><value>/usr/share/gnuradio/fec/ldpc/n_1300_k_0522_gap_30.alist</value></param>
<param><key>gap</key><value>30</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ac</value></param>
<param><key>value</key><value>"1010110011011101101001001110001011110010100011000010000011111100"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ac_site</value></param>
<param><key>value</key><value>"010110011011101100010101011111101001001110001011010001101010001"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>arity</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_code_13</value></param>
<param><key>value</key><value>"1111100110101"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>barker_code_13_2vezes</value></param>
<param><key>value</key><value>"11111001101011111100110101"</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>decoder</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>k</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>frame_size*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TAILBITING</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>decoder</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>256</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[109,79]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TAILBITING</value></param>
</block>
<block>
<key>variable_dummy_decoder_def</key>
<param><key>id</key><value>decoder</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>framebits</key><value>frame_size*8</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_ldpc_bit_flip_decoder_def</key>
<param><key>id</key><value>decoder</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>matrix_object</key><value>G</value></param>
<param><key>max_iterations</key><value>100</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_ldpc_bit_flip_decoder_def</key>
<param><key>id</key><value>decoder</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>matrix_object</key><value>H</value></param>
<param><key>max_iterations</key><value>100</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_ldpc_decoder_def</key>
<param><key>id</key><value>decoder</value></param>
<param><key>file</key><value>gr.prefix() + "/share/gnuradio/fec/ldpc/" + "n_0100_k_0042_gap_02.alist"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max_iter</key><value>50</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>sigma</key><value>0.5</value></param>
</block>
<block>
<key>variable_repetition_decoder_def</key>
<param><key>id</key><value>decoder</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>framebits</key><value>frame_size*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>rep</key><value>3</value></param>
<param><key>prob</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>documentacao</value></param>
<param><key>value</key><value>"1010010011110010"</value></param>
</block>
<block>
<key>variable_ccsds_encoder_def</key>
<param><key>id</key><value>encoder</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>framebits</key><value>frame_size*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TAILBITING</value></param>
</block>
<block>
<key>variable_ccsds_encoder_def</key>
<param><key>id</key><value>encoder</value></param>
<param><key>framebits</key><value>256</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TAILBITING</value></param>
</block>
<block>
<key>variable_dummy_encoder_def</key>
<param><key>id</key><value>encoder</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>framebits</key><value>frame_size*8</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_ldpc_encoder_G_def</key>
<param><key>id</key><value>encoder</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>G</key><value>G</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_ldpc_encoder_H_def</key>
<param><key>id</key><value>encoder</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>H</key><value>H</value></param>
</block>
<block>
<key>variable_ldpc_encoder_def</key>
<param><key>id</key><value>encoder</value></param>
<param><key>file</key><value>gr.prefix() + "/share/gnuradio/fec/ldpc/" + "n_0100_k_0042_gap_02.alist"</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ndim</key><value>0</value></param>
</block>
<block>
<key>variable_repetition_encoder_def</key>
<param><key>id</key><value>encoder</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>framebits</key><value>frame_size*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>rep</key><value>3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>eq_gain</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>gui_hint</key><value>6,2</value></param>
<param><key>label</key><value>Equalizer: rate (Gain)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>0.1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>3,2,1,1</value></param>
<param><key>label</key><value>Frequency Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-0.1</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>0.1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequencia_usrp</value></param>
<param><key>value</key><value>435000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_volt</value></param>
<param><key>value</key><value>0.0000</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label</key><value>Noise Voltage</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_bw</value></param>
<param><key>value</key><value>6.28/100.0</value></param>
<param><key>gui_hint</key><value>6,1</value></param>
<param><key>label</key><value>Phase: Bandwidth</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1.0</value></param>
<param><key>widget</key><value>dial</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polys</value></param>
<param><key>value</key><value>[109, 79]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preambulo_documentacao</value></param>
<param><key>value</key><value>"1010010011110010"</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>qpsk</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable_constellation_rect</key>
<param><key>id</key><value>qpsk</value></param>
<param><key>const_points</key><value>[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]</value></param>
<param><key>imag_sect</key><value>2</value></param>
<param><key>real_sect</key><value>2</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>sym_map</key><value>[0, 1, 2, 3]</value></param>
<param><key>w_imag_sect</key><value>1</value></param>
<param><key>w_real_sect</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250000</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>label</key><value>samp_rate</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10000000</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_channel_model</value></param>
<param><key>value</key><value>[1.0]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>time_offset</value></param>
<param><key>value</key><value>1.00</value></param>
<param><key>gui_hint</key><value>3,3,1,1</value></param>
<param><key>label</key><value>Timing Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.999</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>stop</key><value>1.001</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>timing_loop_bw</value></param>
<param><key>value</key><value>6.28/100.0</value></param>
<param><key>gui_hint</key><value>6,3</value></param>
<param><key>label</key><value>Time: BW</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>0.2</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>variable_qtgui_range_0</value></param>
<param><key>value</key><value>34</value></param>
<param><key>gui_hint</key><value>0,2</value></param>
<param><key>label</key><value>Gain_TX</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>90</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>variable_qtgui_range_0_1</value></param>
<param><key>value</key><value>50</value></param>
<param><key>gui_hint</key><value>0,3</value></param>
<param><key>label</key><value>Gain_RX</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>73</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/andre/Desktop/transmitido/depois.txt</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/andre/Desktop/transmitido/img.jpg</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_1_0</value></param>
<param><key>file</key><value>/home/andre/Desktop/transmitido/depois.mpg</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/andre/Desktop/transmit_maior.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/andre/Desktop/img.jpg</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_0_0</value></param>
<param><key>file</key><value>/home/andre/Desktop/video.mpg</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/andre/Desktop/videofhd.mpg</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/andre/Desktop/trasmit_1_mb.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>align_output</key><value>True</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value></value></param>
<param><key>align_output</key><value>True</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_1</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value></value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1_1</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1_2</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1_3</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_1_4</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0</value></param>
<param><key>map</key><value>-1, 1</value></param>
</block>
<block>
<key>extremly_simple_packet_encoder_and_modulation</key>
<param><key>id</key><value>extremly_simple_packet_encoder_and_modulation_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>eq_gain</key><value>0.01</value></param>
<param><key>freq_offset</key><value>0</value></param>
<param><key>noise_volt</key><value>0.0000</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>timing_loop_bw</key><value>6.28/100.0</value></param>
<param><key>access_code</key><value>AC_documentacao_2_DEFAULT</value></param>
<param><key>payload_length</key><value>0</value></param>
<param><key>preambulo</key><value>""</value></param>
<param><key>samp_rate</key><value>250000</value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>extremly_simple_packet_encoder_and_soft_modulation</key>
<param><key>id</key><value>extremly_simple_packet_encoder_and_soft_modulation_0</value></param>
<param><key>eq_gain</key><value>0.01</value></param>
<param><key>freq_offset</key><value>0</value></param>
<param><key>noise_volt</key><value>0.0000</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>timing_loop_bw</key><value>6.28/100.0</value></param>
<param><key>access_code</key><value>AC_documentacao_2_DEFAULT</value></param>
<param><key>payload_length</key><value>0</value></param>
<param><key>preambulo</key><value>""</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0</value></param>
<param><key>decoder_list</key><value>decoder</value></param>
<param><key>puncpat</key><value>puncpat</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>fec_extended_encoder</key>
<param><key>id</key><value>fec_extended_encoder_1</value></param>
<param><key>encoder_list</key><value>encoder</value></param>
<param><key>puncpat</key><value>puncpat</value></param>
<param><key>threadtype</key><value>none</value></param>
</block>
<block>
<key>fec_extended_encoder</key>
<param><key>id</key><value>fec_extended_encoder_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>encoder_list</key><value>encoder</value></param>
<param><key>puncpat</key><value>puncpat</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_size</value></param>
<param><key>label</key><value>Frame Size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Dos exemplos de do GIT</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>Do pdf</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>DUMMY É CAPILLARY</value></param>
</block>
<block>
<key>only_extremly_simple_soft_modulation</key>
<param><key>id</key><value>only_extremly_simple_soft_modulation_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>eq_gain</key><value>0.01</value></param>
<param><key>freq_offset</key><value>0</value></param>
<param><key>noise_volt</key><value>0.0000</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>timing_loop_bw</key><value>6.28/100.0</value></param>
<param><key>access_code</key><value>AC_documentacao_2_DEFAULT</value></param>
<param><key>payload_length</key><value>0</value></param>
<param><key>preambulo</key><value>""</value></param>
<param><key>samp_rate</key><value>250000</value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>puncpat</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'11'</value></param>
</block>
<block>
<key>simple_packet_encoder_and_modulation</key>
<param><key>id</key><value>simple_packet_encoder_and_modulation_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>eq_gain</key><value>eq_gain</value></param>
<param><key>freq_offset</key><value>freq_offset</value></param>
<param><key>noise_volt</key><value>0</value></param>
<param><key>phase_bw</key><value>0.0628</value></param>
<param><key>timing_loop_bw</key><value>6.28/100.0</value></param>
<param><key>access_code</key><value>AC_documentacao_2_DEFAULT</value></param>
<param><key>payload_length</key><value>996</value></param>
<param><key>preambulo</key><value>""</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>simple_packet_encoder_and_soft_modulation</key>
<param><key>id</key><value>simple_packet_encoder_and_soft_modulation_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>eq_gain</key><value>0.01</value></param>
<param><key>freq_offset</key><value>0</value></param>
<param><key>noise_volt</key><value>0.0000</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>timing_loop_bw</key><value>6.28/100.0</value></param>
<param><key>access_code</key><value>AC_documentacao_2_DEFAULT</value></param>
<param><key>payload_length</key><value>0</value></param>
<param><key>preambulo</key><value>""</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>simple_pkt_encoder_and_pkt_decoder</key>
<param><key>id</key><value>simple_pkt_encoder_and_pkt_decoder_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>access_code</key><value>AC_documentacao_2_DEFAULT</value></param>
<param><key>payload_length</key><value>0</value></param>
<param><key>preambulo</key><value>""</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>blocks_throttle_0_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_0</source_block_id><sink_block_id>blocks_throttle_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_0_0</source_block_id><sink_block_id>blocks_throttle_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0_0_0_0</source_block_id><sink_block_id>blocks_throttle_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_1</source_block_id><sink_block_id>blocks_throttle_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>blocks_throttle_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>blocks_throttle_0_1_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_1</source_block_id><sink_block_id>blocks_throttle_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>extremly_simple_packet_encoder_and_modulation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>extremly_simple_packet_encoder_and_soft_modulation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>only_extremly_simple_soft_modulation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>simple_packet_encoder_and_modulation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>simple_packet_encoder_and_soft_modulation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>simple_pkt_encoder_and_pkt_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1</source_block_id><sink_block_id>blocks_file_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1</source_block_id><sink_block_id>blocks_file_sink_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1_0</source_block_id><sink_block_id>blocks_repack_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1_0_0</source_block_id><sink_block_id>fec_extended_encoder_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1_0_0</source_block_id><sink_block_id>fec_extended_encoder_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1_0_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1_1</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1_2</source_block_id><sink_block_id>fec_extended_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1_3</source_block_id><sink_block_id>digital_map_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_1_4</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0</source_block_id><sink_block_id>blocks_throttle_0_1_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extremly_simple_packet_encoder_and_modulation_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extremly_simple_packet_encoder_and_soft_modulation_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0</source_block_id><sink_block_id>blocks_throttle_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_encoder_1</source_block_id><sink_block_id>blocks_throttle_0_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_encoder_1_0</source_block_id><sink_block_id>blocks_throttle_0_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>only_extremly_simple_soft_modulation_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>simple_packet_encoder_and_modulation_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>simple_packet_encoder_and_soft_modulation_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>simple_pkt_encoder_and_pkt_decoder_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
