<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>packet_tx</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filt_delay</value></param>
<param><key>value</key><value>1+(taps_per_filt-1)/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>header_formatter</value></param>
<param><key>value</key><value>digital.packet_header_default(hsize,length_tag_key)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hsize</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>length_tag_key</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_per_filt</value></param>
<param><key>value</key><value>len(psf_taps)/nfilts</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>hdr_const.bits_per_symbol()</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>pld_const.bits_per_symbol()</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
<param><key>packet_len</key><value>96</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>c</key><value>sps</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_mux</key>
<param><key>id</key><value>blocks_tagged_stream_mux_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
<param><key>ninputs</key><value>2</value></param>
</block>
<block>
<key>digital_burst_shaper_xx</key>
<param><key>id</key><value>digital_burst_shaper_xx_0</value></param>
<param><key>alias</key><value>burst_shaper0</value></param>
<param><key>insert_phasing</key><value>True</value></param>
<param><key>length_tag_name</key><value>packet_len</value></param>
<param><key>post_padding</key><value>filt_delay</value></param>
<param><key>pre_padding</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>window</key><value>firdes.window(firdes.WIN_HANN, 20, 0)</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>hdr_const.points()</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>pld_const.points()</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_1</value></param>
<param><key>check</key><value>False</value></param>
</block>
<block>
<key>digital_crc32_bb</key>
<param><key>id</key><value>digital_crc32_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
<param><key>check</key><value>False</value></param>
<param><key>packed</key><value>True</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_1</value></param>
<param><key>map</key><value>hdr_const.pre_diff_code()</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_1_0</value></param>
<param><key>map</key><value>pld_const.pre_diff_code()</value></param>
</block>
<block>
<key>digital_packet_headergenerator_bb</key>
<param><key>id</key><value>digital_packet_headergenerator_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>header_formatter</key><value>header_formatter.formatter()</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
</block>
<block>
<key>digital_protocol_formatter_async</key>
<param><key>id</key><value>digital_protocol_formatter_async_0</value></param>
<param><key>format</key><value>hdr_format</value></param>
</block>
<block>
<key>fec_async_encoder</key>
<param><key>id</key><value>fec_async_encoder_0</value></param>
<param><key>encoder</key><value>pld_enc</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>packed</key><value>True</value></param>
<param><key>rev_pack</key><value>False</value></param>
<param><key>rev_unpack</key><value>False</value></param>
</block>
<block>
<key>fec_async_encoder</key>
<param><key>id</key><value>fec_async_encoder_0_0</value></param>
<param><key>encoder</key><value>hdr_enc</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>packed</key><value>True</value></param>
<param><key>rev_pack</key><value>False</value></param>
<param><key>rev_unpack</key><value>False</value></param>
</block>
<block>
<key>fec_generic_encoder</key>
<param><key>id</key><value>fec_generic_encoder_0</value></param>
<param><key>encoder</key><value>pld_enc</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>itype</key><value>byte</value></param>
<param><key>otype</key><value>byte</value></param>
</block>
<block>
<key>fec_generic_encoder</key>
<param><key>id</key><value>fec_generic_encoder_1</value></param>
<param><key>encoder</key><value>hdr_enc</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>itype</key><value>byte</value></param>
<param><key>otype</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hdr_const</value></param>
<param><key>label</key><value>Header constellation</value></param>
<param><key>value</key><value>digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hdr_enc</value></param>
<param><key>label</key><value>Header FEC encoder</value></param>
<param><key>value</key><value> fec.dummy_encoder_make(8000)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hdr_format</value></param>
<param><key>label</key><value>Header Formatter</value></param>
<param><key>value</key><value>digital.header_format_default(digital.packet_utils.default_access_code, 0)</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>mod_header</value></param>
<param><key>stream_id</key><value>Mod Header</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>mod_payload</value></param>
<param><key>stream_id</key><value>Mod Payload</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>postcrc</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>mux</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>burst</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>nfilts</key><value>nfilts</value></param>
<param><key>rrate</key><value>sps</value></param>
<param><key>samp_delay</key><value>filt_delay</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>taps</key><value>psf_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pld_const</value></param>
<param><key>label</key><value>Payload constellation</value></param>
<param><key>value</key><value>digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pld_enc</value></param>
<param><key>label</key><value>Payload FEC encoder</value></param>
<param><key>value</key><value> fec.dummy_encoder_make(8000)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>psf_taps</value></param>
<param><key>label</key><value>Pulse Shape Filter</value></param>
<param><key>value</key><value>[0,]</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>rx_mod_header</value></param>
<param><key>stream_id</key><value>Mod Header</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>rx_mod_payload</value></param>
<param><key>stream_id</key><value>Mod Payload</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples per Symbol</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2</value></param>
</block>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>digital_map_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>digital_map_bb_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>digital_crc32_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>digital_burst_shaper_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_mux_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_burst_shaper_xx_0</source_block_id><sink_block_id>pad_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_burst_shaper_xx_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>mod_header</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>mod_payload</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1</source_block_id><sink_block_id>fec_async_encoder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_0</source_block_id><sink_block_id>digital_packet_headergenerator_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_0</source_block_id><sink_block_id>fec_generic_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_1</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_1_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_packet_headergenerator_bb_0</source_block_id><sink_block_id>fec_generic_encoder_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_protocol_formatter_async_0</source_block_id><sink_block_id>fec_async_encoder_0_0</sink_block_id><source_key>header</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_protocol_formatter_async_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>payload</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>fec_async_encoder_0</source_block_id><sink_block_id>digital_protocol_formatter_async_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>fec_async_encoder_0_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>fec_generic_encoder_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_generic_encoder_1</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>digital_crc32_async_bb_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_mod_header</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_mod_payload</source_block_id><sink_block_id>blocks_tagged_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
